# Repository matthewcieplak/super-sixteen (continued)

## KiCad design kicad-control-board/kicad-control-board.kicad_pcb

Parts:
C1, C4, C7: 47uF; CP_Radial_D6.3mm_P2.50mm
C2, C5, C8: 100nF; C_Disc_D5.0mm_W2.5mm_P2.50mm
C3, C6, C9: 100pF; C_Disc_D5.0mm_W2.5mm_P2.50mm
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17: LED; LED3mm
D18: GlideLED; LED3mm
D19: BAT85; D_A-405_P7.62mm_Horizontal
J1: Conn_01x10_Female; Pin_Header_Straight_1x10_Pitch2.54mm
J2: Conn_01x16_Male; Pin_Header_Straight_1x16_Pitch2.54mm
J3: BA56_3DIG_7SEG
J4: Gate Out; PJ301M-12
J5: Clock Out; PJ301M-12
J6: Clock In; PJ301M-12
J7: Pitch Out; PJ301M-12
J8: CV Out; PJ301M-12
J9: Reset In; PJ301M-12
Q1, Q2, Q3: 2N3906; TO-92_Inline_Wide
Q4, Q5: 2N3904; TO-92_Inline_Wide
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12: 100; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R13, R17, R18: 1k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R14, R15, R16: 680; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R19, R22: 10k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R20, R23: 100k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R21, R24: 1M; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
RV1, RV2, RV3, RV4: B100K; Potentiometer_Alps_RK09K_Horizontal
S1, S2, S3, S4, S5, S6, S7, S8, S9, S10, S11, S12, S13, S14, S15, S16: SW; SW_TH_Tactile_Omron_B3F-10xx
S17: Load; SW_TH_Tactile_Omron_B3F-10xx
S18: Save; SW_TH_Tactile_Omron_B3F-10xx
S19: Play; SW_TH_Tactile_Omron_B3F-10xx
S20: Shift; SW_TH_Tactile_Omron_B3F-10xx
S21: GlideBtn; SW_TH_Tactile_Omron_B3F-10xx
SW1: Repeat; Push_E-Switch_KS01Q01
SW2: Mutate; Push_E-Switch_KS01Q01
SW3: Rotary_Encoder; RotaryEncoder_Alps_EC12E_Vertical_H20mm
U1, U3: 74HC595; DIP-16_W7.62mm
U2: MCP23S17; DIP-28_W7.62mm

Connections:
+5V: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, J1.1, Q1.1 (E), Q2.1 (E), Q3.1 (E), R19.1, R22.1, RV1.3, RV2.3, RV3.3, RV4.3, U1.10 (~SRCLR), U1.16 (VCC), U2.9 (VCC), U3.10 (~SRCLR), U3.16 (VCC)
/A0: S20.4, U2.1 (GPB0)
/A1: S17.4, U2.2 (GPB1)
/A2: S18.4, U2.3 (GPB2)
/A3: S19.4, U2.4 (GPB3)
/A4: SW1.2, U2.5 (GPB4)
/A5: SW2.2, U2.6 (GPB5)
/A6: S21.2, U2.7 (GPB6)
/A7: R17.1, U2.8 (GPB7)
AD1: J2.1, RV1.2
AD2: J2.2, RV2.2
AD3: J2.3, RV3.2
AD4: J2.4, RV4.2
CS0: J2.15, U2.11 (~CS)
CS1: J2.11, U1.12 (RCLK)
CS1A: J1.3, U3.12 (RCLK)
CV: J2.8, J8.3
ClockIn: J2.10, Q4.3 (C), R19.2
ClockOut: J2.6, J5.3
DIG1: J1.4, R14.2
DIG2: J1.5, R15.2
DIG3: J1.6, R16.2
ENC1: J1.10, SW3.A
ENC2: J1.9, SW3.B
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, D18.1 (K), D19.2 (A), J1.7, J1.8, J4.1, J5.1, J6.1, J7.1, J8.1, J9.1, Q4.1 (E), Q5.1 (E), R13.1, R21.2, R24.2, RV1.1, RV2.1, RV3.1, RV4.1, S17.2, S18.2, S19.2, S20.2, S21.4, SW1.1, SW2.1, SW3.C, U1.8 (GND), U1.13 (~OE), U2.10 (GND), U2.15 (A0), U2.16 (A1), U2.17 (A2), U3.8 (GND), U3.13 (~OE)
Gate: D17.2 (A), D19.1 (K), J2.5, R18.2
MISO: J2.14, U2.14 (SO)
MOSI: J2.13, U1.14 (SER), U2.13 (SI)
unnamed: D1.1 (K), D5.1 (K), D9.1 (K), D13.1 (K), U1.4 (QE)
unnamed: D1.2 (A), D2.2 (A), D3.2 (A), D4.2 (A), R1.2
unnamed: D5.2 (A), D6.2 (A), D7.2 (A), D8.2 (A), R2.1
unnamed: D2.1 (K), D6.1 (K), D10.1 (K), D14.1 (K), U1.5 (QF)
unnamed: D9.2 (A), D10.2 (A), D11.2 (A), D12.2 (A), R3.1
unnamed: D3.1 (K), D7.1 (K), D11.1 (K), D15.1 (K), U1.6 (QG)
unnamed: D4.1 (K), D8.1 (K), D12.1 (K), D16.1 (K), U1.7 (QH)
unnamed: D13.2 (A), D14.2 (A), D15.2 (A), D16.2 (A), R4.1
unnamed: D17.1 (K), R13.2
unnamed: D18.2 (A), R17.2
unnamed: J3.1 (E), R9.2
unnamed: J3.2 (D), R8.2
unnamed: J3.3 (DP), R12.2
unnamed: J3.4 (C), R7.2
unnamed: J3.5 (G), R11.2
unnamed: J3.7 (B), R6.2
unnamed: J3.8 (DIGIT_3), Q3.3 (C)
unnamed: J3.9 (DIGIT_2), Q2.3 (C)
unnamed: J3.10 (F), R10.2
unnamed: J3.11 (A), R5.2
unnamed: J3.12 (DIGIT_1), Q1.3 (C)
unnamed: J4.3, R18.1
unnamed: J6.3, R20.2
unnamed: J9.3, R23.2
unnamed: Q1.2 (B), R14.1
unnamed: Q2.2 (B), R15.1
unnamed: Q3.2 (B), R16.1
unnamed: Q4.2 (B), R20.1, R21.1
unnamed: Q5.2 (B), R23.1, R24.1
unnamed: R1.1, U1.15 (QA)
unnamed: R2.2, U1.1 (QB)
unnamed: R3.2, U1.2 (QC)
unnamed: R4.2, U1.3 (QD)
unnamed: R5.1, U3.15 (QA)
unnamed: R6.1, U3.1 (QB)
unnamed: R7.1, U3.2 (QC)
unnamed: R8.1, U3.3 (QD)
unnamed: R9.1, U3.4 (QE)
unnamed: R10.1, U3.5 (QF)
unnamed: R11.1, U3.6 (QG)
unnamed: R12.1, U3.7 (QH)
unnamed: S1.1, S5.1, S9.1, S13.1, U2.24 (GPA3)
unnamed: S1.4, S2.4, S3.4, S4.4, U2.28 (GPA7)
unnamed: S5.4, S6.4, S7.4, S8.4, U2.27 (GPA6)
unnamed: S2.1, S6.1, S10.1, S14.1, U2.23 (GPA2)
unnamed: S9.4, S10.4, S11.4, S12.4, U2.26 (GPA5)
unnamed: S3.1, S7.1, S11.1, S15.1, U2.22 (GPA1)
unnamed: S4.1, S8.1, S12.1, S16.1, U2.21 (GPA0)
unnamed: S13.4, S14.4, S15.4, S16.4, U2.25 (GPA4)
unnamed: U1.9 (QH'), U3.14 (SER)
Pitch: J2.7, J7.3
ResetIn: J2.9, Q5.3 (C), R22.2
SCK: J2.12, U1.11 (SRCLK), U2.12 (SCK)
SCKA: J1.2, U3.11 (SRCLK)
SPI_Reset: J2.16, U2.18 (~RESET)

Notes on the sheet:
ANALOG KNOBS
FUNCTION BUTTONS
INPUT/OUTPUT JACKS
LED MATRIX

Board: 2 copper layers, 100.0 x 110.0 mm, 99 parts (2 on the bottom side), 83 nets.

Other parts of the board:
 : WEEE-Logo_5.6x8mm_SilkScreen
  : OSHW-Logo2_7.3x6mm_SilkScreen

## KiCad design kicad-cpu-board-smt/kicad-cpu-board-smt.kicad_pcb

Parts:
C1, C4, C5, C6, C9, C13, C14: 100nF; C_0603_HandSoldering; MFG Part Number CC0603KRX7R9BB104; LCSC Part Number C14663
C2, C10, C12: 47uF; CP_Elec_6.3x7.7; MFG Part Number VES470M1HTR-0607; LCSC Part Number C108053
C3: 1uF; CP_Elec_4x5.3; MFG Part Number VES470M1HTR-0607; LCSC Part Number C108053
C7, C8, C15, C16: 22pf; C_0603_HandSoldering; MFG Part Number CL10C220JB8NNNC; LCSC Part Number C1653
C11: 220uF; CP_Elec_10x10; MFG Part Number VZH221M1VTR-1010K; LCSC Part Number C134521
D1, D2: 1SMA4733A; D_SMA_Handsoldering; MFG Part Number 1SMA4733A; LCSC Part Number C173487
D3, D4: M7; D_SMA_Handsoldering; MFG Part Number M7; LCSC Part Number C95872
J1: ICSP Header; Pin_Header_Straight_2x03_Pitch2.54mm
J2: Conn_01x10_Male; Pin_Header_Straight_1x10_Pitch2.54mm
J3: Conn_01x16_Female; Pin_Header_Straight_1x16_Pitch2.54mm
J4: Conn_02x05_Odd_Even; Pin_Header_Straight_2x05_Pitch2.54mm
L1, L2, L3: 220uH; L_1210_HandSoldering; MFG Part Number NLV32T-221J-PF; LCSC Part Number C89015
Q1, Q2, Q3, Q4: 2N7002; SOT-23_Handsoldering; MFG Part Number 2N7002; LCSC Part Number C8545
R1: 1M; R_0603_HandSoldering; MFG Part Number 0603WAF1004T5E; LCSC Part Number C22935
R2, R14, R15, R17, R18: 10k; R_0603_HandSoldering; MFG Part Number 0603WAF1002T5E; LCSC Part Number C25804
R3, R4, R13, R16: 1k; R_0603_HandSoldering; MFG Part Number 0603WAF1001T5E; LCSC Part Number C21190
R5, R6, R7, R8, R9, R10, R11, R12: 1K; R_0603_HandSoldering; MFG Part Number 0603WAF1001T5E; LCSC Part Number C21190
U1: AMS1117-5.0; SOT-223-3_TabPin2; MFG Part Number AMS1117-5.0; LCSC Part Number C6187
U2: AMS1117-3.3; SOT-223-3_TabPin2; MFG Part Number AMS1117-3.3; LCSC Part Number C6186
U3: ATmega328P-AU; TQFP-32_7x7mm_Pitch0.8mm
U4: W25Q80DVSN; SOIC-8_3.9x4.9mm_Pitch1.27mm; MFG Part Number W25Q80DVSNIG TR; LCSC Part Number C401655
U5: TL072; SOIC-8_3.9x4.9mm_Pitch1.27mm; MFG Part Number TL072CDT; LCSC Part Number C6961
U6: MCP4822; SOIC-8_3.9x4.9mm_Pitch1.27mm; MFG Part Number MCP4822-E/SN; LCSC Part Number C16040
Y1: 16mHz; Crystal_SMD_3225-4pin_3.2x2.5mm_HandSoldering

Connections:
+3V3: C10.1, C13.1, Q1.1 (G), Q2.1 (G), Q3.1 (G), Q4.1 (G), R5.1, R7.1, R9.1, R11.1, U2.2 (VO), U4.3 (IO2), U4.7 (IO3), U4.8 (VCC)
+5V: C2.1, C3.1, C4.1, C6.1, C14.1, J1.2, J2.1, L1.2, R2.1, R6.1, R8.1, R10.1, R12.1, U1.2 (VO), U3.4 (VCC), U3.6 (VCC), U3.20 (AREF), U6.1 (Vdd)
+12V: C1.1, C9.1, C11.1, L2.1, U1.3 (VI), U2.3 (VI), U5.8 (V+)
-12VA: C12.2, L3.1, U5.4 (V-)
AD1: J3.1, U3.23 (PC0)
AD2: J3.2, U3.24 (PC1)
AD3: J3.3, U3.25 (PC2)
AD4: J3.4, U3.26 (PC3)
CS0: J3.15, U3.14 (PB2)
CS1: J2.3, J3.11, U3.13 (PB1)
CS2: Q3.3 (D), R10.2, U3.12 (PB0)
CS3: U3.31 (PD1), U6.2 (~CS)
CV: J3.8, R16.1, R18.1
ClockIn: J3.10, U3.1 (PD3)
ClockOut: J3.6, R4.1
DIG1: J2.4, U3.9 (PD5)
DIG2: J2.5, U3.10 (PD6)
DIG3: J2.6, U3.11 (PD7)
ENC1: J2.10, U3.27 (PC4)
ENC2: J2.9, U3.28 (PC5)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.1, C8.1, C9.2, C10.2, C11.2, C12.1, C13.2, C14.2, D1.2 (A), D2.2 (A), J1.6, J2.7, J2.8, J4.3, J4.4, J4.5, J4.6, J4.7, J4.8, R14.2, R17.2, U1.1 (GND), U2.1 (GND), U3.3 (GND), U3.5 (GND), U3.21 (GND), U4.4 (GND), U6.5 (~LDAC), U6.7 (Vss), Y1.2, Y1.4
Gate: J3.5, R3.1
MISO: J1.1, J3.14, Q2.3 (D), R8.2, U3.16 (PB4)
MOSI: J1.4, J3.13, Q4.3 (D), R12.2, U3.15 (PB3), U6.4 (SDI)
unnamed: C5.1, L1.1, U3.18 (AVCC)
unnamed: C7.2, R1.2, U3.7 (XTAL1/PB6), Y1.1
unnamed: C8.2, R1.1, U3.8 (XTAL2/PB7), Y1.3
unnamed: C15.1, R13.2, U5.1
unnamed: C15.2, R14.1, R15.2, U5.2 (-)
unnamed: C16.1, R16.2, U5.7
unnamed: C16.2, R17.1, R18.2, U5.6 (-)
unnamed: D1.1 (K), R3.2, U3.30 (PD0)
unnamed: D2.1 (K), R4.2, U3.32 (PD2)
unnamed: D3.1 (K), L2.2
unnamed: D3.2 (A), J4.1, J4.2
unnamed: D4.1 (K), J4.9, J4.10
unnamed: D4.2 (A), L3.2
unnamed: Q1.2 (S), R5.2, U4.6 (CLK)
unnamed: Q2.2 (S), R7.2, U4.2 (DO(IO1))
unnamed: Q3.2 (S), R9.2, U4.1 (~CS)
unnamed: Q4.2 (S), R11.2, U4.5 (DI(IO0))
unnamed: U5.3 (+), U6.8 (VA)
unnamed: U5.5 (+), U6.6 (VB)
Pitch: J3.7, R13.1, R15.1
RESET: J1.5, J3.16, R2.2, U3.29 (~RESET~/PC6)
ResetIn: J3.9, U3.2 (PD4)
SCK: J1.3, J2.2, J3.12, Q1.3 (D), R6.2, U3.17 (PB5), U6.3 (SCK)

Notes on the sheet:
5V REGULATOR
ATMEGA 328P
FLASH MEMORY
LEVEL SHIFTING
DAC & OUTPUT BUFFER
3.3V REGULATOR
SUPER SIXTEEN SEQUENCER
POWER CONNECTOR

Board: 2 copper layers, 78.5 x 69.0 mm, 56 parts (2 on the bottom side), 47 nets.

File kicad-cpu-board-smt/bom/kicad-cpu-board-bom-smt.xlsx:

Item Number | Comment | Do Not Install | Quantity | Reference Designators | Footprint | Vendor | Vendor Part # | Manufacturer Part # | Manufacturer
1 | 220uF |  | 1 | C11 | Capacitors_SMD:CP_Elec_10x10 | Digikey | 493-2179-6-ND | UWT1C221MCL1GS | Nichicon
2 | 47uF |  | 3 | C12,C10,C2 | Capacitors_SMD:CP_Elec_6.3x7.7 | Digikey | 493-2225-6-ND | UWT1H470MCL1GS | Nichicon
3 | 100nF |  | 7 | C13,C9,C1,C14,C6,C5,C4 | Capacitors_SMD:C_0603_HandSoldering | Digikey | 399-1100-6-ND | C0603C104Z3VACTU | Kemet
4 | 22pf |  | 4 | C16,C15,C7,C8 | Capacitors_SMD:C_0603_HandSoldering | Digikey | 399-7874-6-ND | C0603C220J1GACTU | Kemet
5 | 1uF |  | 1 | C3 | Capacitors_SMD:CP_Elec_4x5.3 | Digikey | 493-9985-6-ND | UUX2G010MNL1GS | Nichicon
6 | 1SMB5918BT3G |  | 2 | D2,D1 | Diodes_SMD:D_SMA-SMB_Universal_Handsoldering | Digikey | 1SMB5918BT3GOSDKR-ND | 1SMB5918BT3G | ON Semiconductor
7 | S1KB |  | 2 | D4,D3 | Diodes_SMD:D_SMA-SMB_Universal_Handsoldering | Digikey | S1KB-FDIDKR-ND | S1KB-13-F | Diodes Incorporated
8 | ICSP Header | DNI | 1 | J1 | Pin_Headers:Pin_Header_Straight_2x03_Pitch2.54mm | Digikey | 609-3218-ND | 67996-406HLF | Amphenol
9 | Conn_01x10_Male | DNI | 1 | J2 | Pin_Headers:Pin_Header_Straight_1x10_Pitch2.54mm | Digikey | 609-3285-ND | 68001-410HLF | Amphenol
10 | Conn_01x16_Male | DNI | 1 | J3 | Pin_Headers:Pin_Header_Straight_1x16_Pitch2.54mm | Digikey | 609-3267-ND | 68000-416HLF | Amphenol
11 | Conn_02x05_Odd_Even | DNI | 1 | J4 | Pin_Headers:Pin_Header_Straight_2x05_Pitch2.54mm | Digikey | 609-3243-ND | 67997-410HLF | Amphenol
12 | 220uH |  | 3 | L3,L2,L1 | Inductors_SMD:L_1210_HandSoldering | Digikey | 445-1545-6-ND | NLCV32T-221K-PF | TDK
13 | 2N7002 |  | 4 | Q2,Q4,Q3,Q1 | TO_SOT_Packages_SMD:SOT-23_Handsoldering | Digikey | 2N7002LT1GOSDKR-ND | 2N7002LT1G | ON Semiconductor
14 | 1M |  | 1 | R1 | Resistors_SMD:R_0603_HandSoldering | Digikey | RMCF0603FT1M00DKR-ND | RMCF0603FT1M00 | Stackpole Electronics, Inc
15 | 1k |  | 12 | R16,R4,R3,R12,R11,R8,R7,R6,R5,R10,R9,R13 | Resistors_SMD:R_0603_HandSoldering | Digikey | RMCF0603FT1K00DKR-ND | RMCF0603FT1K00 | Stackpole Electronics, Inc
16 | 10k |  | 5 | R17,R18,R14,R15,R2 | Resistors_SMD:R_0603_HandSoldering | Digikey | RNCP0603FTD10K0DKR-ND | RNCP0603FTD10K0 | Stackpole Electronics, Inc
17 | AMS1117-5.0 |  | 1 | U1 | TO_SOT_Packages_SMD:SOT-223-3_TabPin2 | Digikey | NCP1117ST50T3GOSDKR-ND | NCP1117ST50T3G | ON Semiconductor
18 | AMS1117-3.3 |  | 1 | U2 | TO_SOT_Packages_SMD:SOT-223-3_TabPin2 | Digikey | NCP1117ST33T3GOSDKR-ND | NCP1117ST33T3G | ON Semiconductor
19 | ATmega328P-AU |  | 1 | U3 | Housings_QFP:TQFP-32_7x7mm_Pitch0.8mm | Digikey | ATMEGA328P-AURDKR-ND | ATMEGA328P-AUR | Microchip Technology
20 | W25Q80DVSN |  | 1 | U4 | Housings_SOIC:SOIC-8_3.9x4.9mm_Pitch1.27mm | Digikey | W25Q80DVSNIG-ND | W25Q80DVSNIG | Winbond
21 | TL072 |  | 1 | U5 | Housings_SOIC:SOIC-8_3.9x4.9mm_Pitch1.27mm | Digikey | 296-1282-6-ND | TL072CDR | Texas Instruments
22 | MCP4822 |  | 1 | U6 | Housings_SOIC:SOIC-8_3.9x4.9mm_Pitch1.27mm | Digikey | MCP4822-E/SN-ND | MCP4822-E/SN | Microchip
23 | 16mHz |  | 1 | Y1 | Crystals:Crystal_SMD_3225-4pin_3.2x2.5mm_HandSoldering | Digikey | SER4069DKR-ND | TSX-3225 16.0000MF09Z-AC0 | Epson

## Code that names these connections

File sequencer_app_v2/src/Pinout.h:

#pragma once

namespace supersixteen{

#define GATE_PIN PD0
//#define LDAC_PIN 1
#define CLOCK_OUT_PIN PD2
#define CLOCK_IN_PIN PD3
#define RESET_PIN PD4

#define GLIDE_LED_PIN 15 //these 8 are on the button driver chip, not the MCU
#define GLIDE_PIN 14
#define REPEAT_PIN 13
#define RECORD_PIN 12
#define SAVE_PIN 11 
#define LOAD_PIN 10 
#define PLAY_PIN 9 
#define SHIFT_PIN 8

#define CS0_PIN  10 //MCP23S17 for buttons, aux LEDS
#define CS1_PIN  9  //Display/matrix shift registers
#define CS2_PIN  8  //Flash memory
#define CS3_PIN  1  //DAC PD1

  //DIGIT DISPLAY PINS
#define DIGIT_1_PIN PD5
#define DIGIT_2_PIN PD7
#define DIGIT_3_PIN PD6 

#define GAIN_1  0x1
#define GAIN_2  0x0

#define ANALOG_PIN_1 A0
#define ANALOG_PIN_2 A1
#define ANALOG_PIN_3 A2
#define ANALOG_PIN_4 A3

#define ENC_A_PIN A4
#define ENC_B_PIN A5
#define ENC_PORT PINC

}

## Commit log

2018-07-02 Adding license info.
2018-07-03 Adding arduino demos
2018-07-03 Adding kicad files
2018-07-25 Adding new demos for matrix
2018-07-25 Updating schematic
2018-07-25 Adding calibration value scale to DAC demo
2018-09-09 Updating schematic and PCB
2018-09-09 Adding eurocad parts
2018-09-09 Adding gerber prints
2018-09-25 First draft of sequencer in arduino code
2018-09-26 Implementing timed gate logic
2018-12-15 Adding arduino sketches
2018-12-15 Refactoring arduino code into C++, implementing calibration
2018-12-15 Cleaning up kicad folder
2019-05-28 Adding front panel graphic files
2019-05-28 External sync
2019-05-28 Housekeeping
2019-05-28 New control board PCB
2019-05-28 New CPU board PCB
2019-05-28 Updating backupfile
2019-05-28 Adding original arduino .INO sketch for archival use
2019-05-28 Rebuilding sequencer app for new boards and VS Code+Platform.io instead of Visual Studio
2019-05-30 Updating gitignore for VS code
2019-05-30 Updating vs config
2019-05-30 Rewriting LED/matrix/button logic for new shift register pinout
2019-05-30 Updating kicad gitignore files
2019-06-04 Updating encoder read logic and tempo bpm display
2019-06-04 Refactoring alphanumeric display functions
2019-06-04 Debugging analog i/o, making pots reach max easier
2019-06-04 Updating DAC test sketch
2019-06-04 Ignore IPCH files
2019-06-05 Updating gitattributes to fix language detection
2019-06-06 Starting to reorganize functions into classes
2019-06-06 More refactoring
2019-06-10 Massive refactoring of all flatfiles into classes
2019-06-10 Trying to ignore all ipch files
2019-06-10 Deleting autosave
2019-06-10 More gitignore for VS code
2019-06-10 Fixing compilation, localizing variables
2019-06-10 Nuking IPCH folder
2019-06-11 Fixing LED chase and button registration
2019-06-11 Fixing glide led mask.
2019-06-11 Fixing pitch/gate out
2019-06-12 Adding lightweight event queue library
2019-06-12 Using queue to fix button press events
2019-07-15 Updates to front panel design
2019-07-15 Kicad cache
2019-07-15 Adding motion record, beat repeat, multiplex improvements
2019-07-28 Adding library submodules
2019-09-23 Using struct for sequence
2019-10-06 Local updates
2019-10-06 Style consistency
2019-10-06 Removing boost lib
2019-10-06 Adding libraries to platform ini
2019-10-07 Adding a visual blink to DAC test script
2019-10-07 Implementing patch memory prototype
2019-10-07 Adding panel renders
2019-10-07 Storing sequence settings in memory
2019-10-07 Enable patch storage to selectable address
2019-10-07 Fixing motion record display action
2019-10-07 Fixing glide led/button glitch
2019-10-09 Enabling shift-mode parameter editing for scale, steps, etc
2019-10-09 Implementing scalar quantization
2019-10-10 Fixing low octave glitch
2019-10-10 Adjusting tempo and swing real-time
2019-10-10 Enabling multi-bar sequencing!
2019-10-10 Enabling sequence clear and easy calibration
2019-10-12 Adding selectable FX and octave shift
2019-10-18 Implementing glide and reverse effects
2019-10-18 Implementing freeze and stop effects
2019-10-18 Implementing randomize and stutter functions
2019-10-18 Implementing roll effect
2019-10-18 Enabling CV2 output
2019-10-18 Implementing external reset
2019-10-18 Fixing glitch randomizing with external clock
2019-10-19 Fixing record audition, display flicker when external clocking
2019-10-19 Implementing in-time pickup for diff-length sequences
2019-10-19 Implementing bar copy/paste and fixing no-op button events
2019-10-19 Finally fixing record audition and overwrite bugs
2019-10-20 Enabling shift-record step activate
2019-10-20 Adding simple startup sequence
2019-10-20 Implementing glide adjust and easier tempo edit.
2019-12-11 Updating PCB and schematics for assembly bugfixes
2019-12-11 De-inverting display LEDs
2019-12-11 Read calibration values by default
2019-12-11 Updating front panel graphics
2019-12-11 Adding board fuses for 16mHz operation
2019-12-11 Updating control board gerbers
2019-12-11 Updating CPU board gerbers
2019-12-11 Swapping in 660R resistors
2019-12-11 Updating interactive BOM
2019-12-18 Optimizing gate and stutter timing calculation
2019-12-18 Optimizing resistor values for display
2019-12-18 Fixing voltage regulator packcage
2019-12-18 Adding SMT cpu board project
2019-12-18 Adding SMT cpu board gerbers
2019-12-18 Updating gitignore
2019-12-18 Adding SMT cpu board BOM and position files
2019-12-18 Adding SMT control board project
2019-12-18 Addding SMT control board gerbers
2019-12-18 Adding SMT control board BOM and position files
2020-02-29 Adding fork of serialflash for 4kb erase
2020-02-29 Fixing CPU footprint on SMT board and updating bom + gerbers
2020-02-29 Updating front panel and adding photo assets
2020-02-29 First draft of manual in indesign
2020-02-29 Rerouting traces to avoid potentiometer support lugs shorting to ground
2020-02-29 Adding encoder invert function
2020-02-29 Adding erase memory convenience test function
2020-02-29 Enabling swing with external clock
2020-02-29 Invert encoder via shift function
2020-02-29 Updating serialflash dependency
2020-02-29 Platformio file updates
2020-02-29 Debouncing button presses
2020-02-29 Improving reset button behavior
2020-02-29 Motion record continous changes
2020-05-11 Adding bit-option to flip between common anode/common-cathode
2020-05-11 Amending common-cathode mode for non-inverted character display
2020-05-16 Adding flash memory test
2020-06-18 Updating manual PDF
2020-06-19 Tweaking tracerouting
2020-06-19 Updating SMT BOM files for domestic parts
2020-06-19 Adding part numbers
2020-06-19 Updating SMT BOM file for control board
2020-06-19 Updating VS code
2020-06-19 Fixing button debounce
2020-06-19 Use interrupt for clock input
2020-06-19 Show visual feedback on manual reset.
2020-07-01 Better debouncing to fix simultaneous release.
2020-07-01 Adjusting t and z in font.
2020-07-01 Adding transpose effect.
2020-07-01 Updating firmware build.
2020-07-05 Specifying flash lib fork and enabling manual memory erase.
2020-07-06 Fixing external reset
2020-07-06 Updating firmware
2020-08-02 Deleting redundant panel drawings
2020-08-02 Updating panel design - adding standoff
2020-08-02 Creating PCB panel kicad project
2020-08-02 Adding custom silkscreen bitmaps
2020-08-02 Rendering front panel gerbers
2020-08-02 Manual tweaks
2020-08-02 Importing silkscreen library
2020-08-02 Updating control positions, adding standoff on control PCB
2020-08-02 Updating control positions on SMT version
2020-08-02 Updating control board gerbers and position file (SMT version)
2020-08-02 Incrementing CPU SMT board version
2020-08-02 Updating CPU board berbers
2020-08-02 Adding R values to silkscreen
2020-08-02 Adding logo to control board.
2020-08-02 Fixing clear function scale default.
2020-08-02 Adding interactive BOM for control board
2020-08-02 Adding interactive BOM for CPU board
2020-08-04 Only start recording when a knob is moved
2020-08-04 Fixing auto-quantization of pentatonics
2020-08-04 Enable mutation recording and better step rhythm entry
2020-08-31 Optimizing reset and multiplex subroutines to fix display flicker
2020-08-31 Implementing patch number as default encoder parameter
2020-08-31 Updating control board silkscreen
2020-08-31 Updating SMT control board silkscreen
2020-08-31 Updating CPU board silkscreen
2020-08-31 Updating PCB panel cutout positions
2020-08-31 Using decimal to indicate which patches are occupied
2020-08-31 Store mutation sequence data in memory
2020-09-05 Enabling quicksave/quickload and fixing step record
2020-09-05 Optimizing firmware upload
2020-09-05 Factory reset on 5x clear sequence.
2020-09-05 Fixing unsigned integer comparison.
2020-09-05 1.0 Release for firmware
2020-09-05 Stop display blinking when exiting menu.
2020-11-10 Compiling old sequencer app
2020-12-28 Updating manual and specs
2020-12-28 Organizing SMT BOM
2020-12-30 Enabling note name mode C0, B1 etc toggleable in calibrate menu
2020-12-30 Implementing turing mode to store random pitch changes
2021-01-31 Using turing2 mode for rhythmic alteration.
2021-02-01 Adding images for manual.
2021-02-01 Implementing song mode "next sequence"
2021-02-01 Reformatting user manual and updating for 1.1.
2021-02-01 Updating firmware build to 1.1
2021-03-04 Fixing clock reset desync issue and updating build to 1.1a
2021-03-04 Tweaks to manual
2021-03-04 Updating README
2021-03-04 Fixing image URL
2021-03-04 fixing relative link paths
2021-03-04 Fixing README links.
2021-03-04 Fixing relative directory links.
2021-03-04 Using absolute links for folders. (really github??)
2021-03-04 Typo fix.
2021-03-08 Making SRC folder arduino IDE compatible
2021-05-22 Updating silkscreen on SMT cpu board
2021-05-22 Flipping 2n3906 transistors silkscreen
2021-05-22 Flipping SMT MMBT2N3906 transistor orientation
2021-05-22 Updating CPU board version silkscreen
2021-07-28 Bugfix for sequence loading of different length - adding jog function on shift+encoder - prototype brightness function
2021-07-28 Firmware 1.1b - bugfixes, minor tweaks
2022-01-01 Fixed some filename typos to fix compiling on case-sensitive filesystems
2022-02-19 Enabling note audition w shift+pitch, cleaning up calibration mode display
2022-02-19 Better feedback for encoder invert mode
2022-04-12 Implementing CV2 pitch modes and calibration
2022-04-12 Platform.io version upgrade
2022-04-12 Fixing turing pitch cv2 generation and rec note display
2022-04-12 Implementing smoothed LFO mode for CV2
2022-04-12 Implementing chord and sub osc effect modes
2022-04-20 Enabling vibrato mutation
2022-05-05 Enabling mutate_on_reset input, improving pickup logic
2022-05-05 Update for kicad 6
2022-05-05 Building firmware release 1.2
2022-06-11 Fixing default voltage level to remain consistent with 1.0-1.1
2022-06-11 Release 1.2a
2022-06-11 Applying octave fix to CV2
2023-05-15 Updating manual for 1.2
2023-05-15 Discard 0 octave calibration, better cv adjust range
