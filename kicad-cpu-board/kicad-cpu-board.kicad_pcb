# Repository matthewcieplak/super-sixteen

File README.md:

# Super Sixteen Eurorack Sequencer
Super Sixteen is an open-source/open-hardware sequencer for the Eurorack synthesizer format. It's available through my [web shop](https://store.extralifeinstruments.com) and fine retailers as a complete module and DIY kit. It's developed on the Arduino codebase on Atmega328P, using the [PlatformIO](https://platformio.org/) extension for Visual Studio Code.

At just 20HP, it is a compact and powerful 64-step control voltage sequencer with 99 song patch memory, motion recording, scale selection, realtime pitch and rhythm effects, paraphonic modes, generative mutations, and a uniquely powerful two-handed programming interface.

Video blogs [documenting the sequencer progress are available on youtube](
https://www.youtube.com/playlist?list=PLXcIAQij6ZZKMTHAFv8BHvEnsouNYhx3t).

# Documentation

*   [USER MANUAL (pdf)](graphics/manual_1.1.pdf)
*   [BUILD GUIDE (pdf)](http://extralifeinstruments.com/docs/super-sixteen/build-guide.pdf)
*   [BILL OF MATERIALS (octopart list)](https://octopart.com/bom-tool/Wq51xQ3R)
*   INTERACTIVE BOM (html - for easy part placement) [CPU board](http://extralifeinstruments.com/docs/super-sixteen/ibom-cpu.html) / [Control board](http://extralifeinstruments.com/docs/super-sixteen/ibom-control.html)
*   [Video build guide](https://www.youtube.com/watch?v=RGmp3aG8Nbw&feature=emb_title)
*   [1v/oct calibration tutorial video](https://www.youtube.com/watch?v=QJvS-ma6CHY)
*   [Build support thread on Mod Wiggler](https://modwiggler.com/forum/viewtopic.php?f=97&t=238514)
*   [ModularGrid page](https://modulargrid.net/e/other-unknown-extralife-instruments-super-sixteen)

# Hardware files
Kicad and gerber files for four PCBs are included in this repository. The project is split into two boards, one for the CPU, memory, power, and DAC logic (CPU_board) and one for the front panel controls (control_board). Each board comes in a through-hole version for DIY builders and an SMT version for automated assembly. They are functionally identical but part numbers are different to reflect the different footprints. 

# Software
Primary development of the firmware takes place in [sequencer_app_v2](https://github.com/matthewcieplak/super-sixteen/tree/master/sequencer_app_v2) using the Arduino C++ libraries but compiled using PlatformIO and typical C header files. (The older, pure Arduino version, [sequencer_app](https://github.com/matthewcieplak/super-sixteen/tree/master/sequencer_app) is here only for archival purposes and is unmaintained). You can find the .hex files to upload using the arduino updater in [sequencer_app_v2/build](https://github.com/matthewcieplak/super-sixteen/tree/master/sequencer_app_v2/build). The shell commands for updating using avrdude are contained in [upload.sh](sequencer_app_v2/upload.sh), though you may also use the Arduino IDE to upload new firmware.

# Troubleshooting
Please refer to the [official build support thread on Mod Wiggler](https://modwiggler.com/forum/viewtopic.php?f=97&t=238514) to post a query. You may find your question has already been answered!

Common issues:
* *My sequencer doesn't turn on!* - Check your soldering carefully, under magnification and bright light! 90% of functional issues can be traced to bad connections caused by missing or cold solder joints. A common place to find bad joints is on the header connector pins, as they are on the opposite side of the board from the othres.
* *My soldering is good, now what?*  After that, check the *orientation* of all your ICs closely. A backwards chip or capacitor or diode is easy to miss.
* *The screen shows "nEn" at startup and freezes when I move the encoder* - This message (actually "mEm") is caused by a communication failure between the CPU (Atmega328p) and the memory chip (W25Q80DV). Most often this is caused by soldering issues on the SMT memory chip. Reflow the SMT joints with flux and try again. If it persists, check for 3.3v at pins 8 and 4 of the memory chip. If that fails, you may suspect the 2n7000 transistors nearby (mosfets are fragile) and then potentially check the integrity of the traces between the chip and the resistors. Opening kicad and using the show net tool is helpful for this.
* *I can program sequences but they're not in tune* You need to perform the DAC calibration procedure, as outlined in the manual and [this video tutorial](https://www.youtube.com/watch?v=QJvS-ma6CHY). You'll need a multimeter or electronic tuner.

# License
Code: [GPL3.0](https://www.gnu.org/licenses/gpl-3.0.en.html)
Hardware: [cc-by-sa-3.0](https://creativecommons.org/licenses/by-sa/3.0/deed.en)

By: Matthew Cieplak (matthew.cieplak@gmail.com)

## KiCad design kicad-cpu-board/kicad-cpu-board.kicad_pcb

Parts:
C101, C108, C109, C110: 47uF; CP_Radial_D6.3mm_P2.50mm
C102: 1uF; CP_Radial_D4.0mm_P2.00mm
C103, C104, C106, C111, C112, C115, C116: 100nF; C_Disc_D5.0mm_W2.5mm_P2.50mm
C105, C113, C114: 22pf; C_Disc_D3.0mm_W2.0mm_P2.50mm
C107: 22pf; C_Disc_D3.8mm_W2.6mm_P2.50mm
D101, D102: 1N4733A; D_A-405_P7.62mm_Horizontal
D103, D104: 1N4001; D_DO-15_P10.16mm_Horizontal
J101: ICSP Header; Pin_Header_Straight_2x03_Pitch2.54mm
J102: Conn_01x10_Male; Pin_Header_Straight_1x10_Pitch2.54mm
J103: Conn_01x15_Female; Pin_Header_Straight_1x15_Pitch2.54mm
J104: Conn_02x05_Odd_Even; Pin_Header_Straight_2x05_Pitch2.54mm
L101, L102, L103: L; L_Axial_L5.3mm_D2.2mm_P7.62mm_Horizontal_Vishay_IM-1
Q101, Q102, Q103, Q104: 2N7000; TO-92_Inline_Narrow_Oval
R101: 1M; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R102, R114, R115, R117, R118: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R103, R108, R113, R116: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R104, R105, R106, R107, R109, R110, R111, R112: 1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
U101: L7805; TO-220-3_Horizontal
U102: LP2950-3.3_TO92; TO-92_Inline_Narrow_Oval
U103: ATmega328-PU; DIP-28_W7.62mm
U104: W25Q80DVSN; SOIC-8_3.9x4.9mm_Pitch1.27mm
U105: TL072; DIP-8_W7.62mm
U106: MCP4822; DIP-8_W7.62mm
Y101: 16mHz; Crystal_HC18-U_Vertical

Connections:
+3V3: C108.1, C111.2, Q101.2 (G), Q102.2 (G), Q103.2 (G), Q104.2 (G), R104.1, R106.1, R109.1, R111.1, U102.1 (VO), U104.3 (WP), U104.7 (HOLD), U104.8 (VCC)
+12V: C109.1, C115.1, C116.1, L102.1, U101.1 (IN), U102.3 (VI), U105.8 (V+)
-12VA: C110.2, L103.1, U105.4 (V-)
AD1: J103.1, U103.23 (PC0)
AD2: J103.2, U103.24 (PC1)
AD3: J103.3, U103.25 (PC2)
AD4: J103.4, U103.26 (PC3)
CS0: J103.15, U103.16 (PB2)
CS1: J102.3, J103.11, U103.15 (PB1)
CS2: Q103.3 (D), R110.2, U103.14 (PB0)
CS3: U103.3 (PD1), U106.2 (~CS)
CV: J103.8, R116.1, R118.1
ClockIn: J103.10, U103.5 (PD3)
ClockOut: J103.6, R108.1
DIG1: J102.4, U103.11 (PD5)
DIG2: J102.5, U103.12 (PD6)
DIG3: J102.6, U103.13 (PD7)
ENC1: J102.10, U103.27 (PC4)
ENC2: J102.9, U103.28 (PC5)
GND: C101.2, C102.2, C103.2, C104.2, C105.1, C106.2, C107.1, C108.2, C109.2, C110.1, C111.1, C112.2, C115.2, C116.2, D101.2 (A), D102.2 (A), J101.6, J102.7, J102.8, J104.3, J104.4, J104.5, J104.6, J104.7, J104.8, R114.2, R117.2, U101.2 (GND), U102.2 (GND), U103.8 (GND), U103.22 (GND), U104.4 (GND), U106.5 (~LDAC), U106.7 (Vss)
Gate: J103.5, R103.1
MISO: J101.1, J103.14, Q101.3 (D), R105.2, U103.18 (PB4)
MOSI: J101.4, J103.13, Q102.3 (D), R107.2, U103.17 (PB3), U106.4 (SDI)
unnamed: C104.1, L101.1, U103.20 (AVCC)
unnamed: C105.2, R101.2, U103.9 (XTAL1/PB6), Y101.1
unnamed: C107.2, R101.1, U103.10 (XTAL2/PB7), Y101.2
unnamed: C113.1, R113.2, U105.1
unnamed: C113.2, R114.1, R115.2, U105.2 (-)
unnamed: C114.1, R116.2, U105.7
unnamed: C114.2, R117.1, R118.2, U105.6 (-)
unnamed: D101.1 (K), R103.2, U103.2 (PD0)
unnamed: D102.1 (K), R108.2, U103.4 (PD2)
unnamed: D103.1 (K), L102.2
unnamed: D103.2 (A), J104.1, J104.2
unnamed: D104.1 (K), J104.9, J104.10
unnamed: D104.2 (A), L103.2
unnamed: Q101.1 (S), R104.2, U104.2 (DO)
unnamed: Q102.1 (S), R106.2, U104.5 (DI)
unnamed: Q103.1 (S), R109.2, U104.1 (CS)
unnamed: Q104.1 (S), R111.2, U104.6 (CLK)
unnamed: U105.3 (+), U106.8 (VA)
unnamed: U105.5 (+), U106.6 (VB)
Pitch: J103.7, R113.1, R115.1
RESET: J101.5, J103.16, R102.2, U103.1 (~RESET~/PC6)
ResetIn: J103.9, U103.6 (PD4)
SCK: J101.3, J102.2, J103.12, Q104.3 (D), R112.2, U103.19 (PB5), U106.3 (SCK)

Notes on the sheet:
5V REGULATOR
ATMEGA 328
FLASH MEMORY
LEVEL SHIFTING
DAC & OUTPUT BUFFER
3.3V REGULATOR
SUPER SIXTEEN SEQUENCER
POWER CONNECTOR

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
Board: 2 copper layers, 78.5 x 69.0 mm, 56 parts (2 on the bottom side), 47 nets.

## KiCad design kicad-control-board-smt/kicad-control-board-smt.kicad_pcb

Parts:
C101, C104, C107: 47uF; CP_Elec_6.3x7.7; MFG Part Number VES470M1HTR-0607; LCSC Part Number C108053
C102, C105, C108: 100nF; C_0603_HandSoldering; MFG Part Number C0603C104Z3VACTU; LCSC Part Number C14663
C103, C106, C109: 100pF; C_0603_HandSoldering; MFG Part Number C0603C101J1GACTU; LCSC Part Number C14858
D1: SS54; D_SMA_Handsoldering; MFG Part Number TSS54U RGG; Digikey Part Number TSS54URGGDKR-ND
D101, D102, D103, D104, D105, D106, D107, D108, D110, D111, D112, D113, D114, D115, D116, D117, D118: LED; LED_D3.0mm; MFG Part Number C503B-AAS-CY0B0251; Digikey Part Number C503B-AAS-CY0B0251-ND
D109: GlideLED; LED_D3.0mm; MFG Part Number C503B-AAS-CY0B0251; Digikey Part Number C503B-AAS-CY0B0251-ND
J101: Conn_01x10_Female; Pin_Header_Straight_1x10_Pitch2.54mm; MFG Part Number PPTC101LFBN-RC; Digikey Part Number S7008-ND
J102: Conn_01x16_Female; Pin_Header_Straight_1x16_Pitch2.54mm; MFG Part Number PPTC161LFBN-RC; Digikey Part Number S7014-ND
J103: BA56_3DIG_7SEG; MFG Part Number BA56-12GWA; Digikey Part Number 754-1656-5-ND
J104: Gate Out; PJ301M-12; MFG Part Number WQP-WQP518MA; Digikey Part Number N/A
J105: Clock Out; PJ301M-12; MFG Part Number WQP-WQP518MA; Digikey Part Number N/A
J106: Clock In; PJ301M-12; MFG Part Number WQP-WQP518MA; Digikey Part Number N/A
J107: Pitch Out; PJ301M-12; MFG Part Number WQP-WQP518MA; Digikey Part Number N/A
J108: CV Out; PJ301M-12; MFG Part Number WQP-WQP518MA; Digikey Part Number N/A
J109: Reset In; PJ301M-12; MFG Part Number WQP-WQP518MA; Digikey Part Number N/A
Q101, Q102, Q103: MMBT3906; SOT-23_Handsoldering; MFG Part Number MMBT3906LT1G; LCSC Part Number C53444
Q104, Q105: MMBT3904; SOT-23_Handsoldering; MFG Part Number MMBT3904LT3G; LCSC Part Number C20526
R101, R102, R104, R105, R106, R107, R108, R109, R110, R111, R112, R113: 100; R_0603_HandSoldering; MFG Part Number RMCF0603FT100R; LCSC Part Number C22775
R103, R114, R118: 1k; R_0603_HandSoldering; MFG Part Number RMCF0603FT1K00; Digikey Part Number RMCF0603FT1K00DKR-ND
R115, R116, R117: 680R; R_0603_HandSoldering; MFG Part Number RMCF0603FT680R; LCSC Part Number C23228
R119, R122: 10k; R_0603_HandSoldering; MFG Part Number RMCF0603FT10K0; LCSC Part Number C25804
R120, R123: 100k; R_0603_HandSoldering; MFG Part Number RMCF0603FG100K; LCSC Part Number C25803
R121, R124: 1M; R_0603_HandSoldering; MFG Part Number RMCF0603FT1M00; LCSC Part Number C22935
RV101, RV102, RV103, RV104: R_POT; Potentiometer_Alps_RK09K_Horizontal; MFG Part Number RV09AF-40-20K-B100K; Digikey Part Number N/A
SW101: Shift; SW_PUSH_6mm; MFG Part Number TL1105SPF160Q; Digikey Part Number EG1861-ND
SW102: Play; SW_PUSH_6mm; MFG Part Number TL1105SPF160Q; Digikey Part Number EG1861-ND
SW103: Load; SW_PUSH_6mm; MFG Part Number TL1105SPF160Q; Digikey Part Number EG1861-ND
SW104: Save; SW_PUSH_6mm; MFG Part Number TL1105SPF160Q; Digikey Part Number EG1861-ND
SW105: Repeat; Push_E-Switch_KS01Q01; MFG Part Number D6R40 F2 LFS; Digikey Part Number 401-1992-ND
SW106: Mutate; Push_E-Switch_KS01Q01; MFG Part Number D6R40 F2 LFS; Digikey Part Number 401-1992-ND
SW107: Glide; SW_PUSH_6mm; MFG Part Number TL1105SPF160Q; Digikey Part Number EG1861-ND
SW108, SW109, SW110, SW111, SW112, SW113, SW114, SW115, SW117, SW118, SW119, SW120, SW121, SW122, SW123, SW124: SW_Push; SW_PUSH_6mm; MFG Part Number TL1105SPF160Q; Digikey Part Number EG1861-ND
SW116: Rotary_Encoder; RotaryEncoder_Alps_EC12E_Vertical_H20mm; MFG Part Number PEC11R-4215F-N0024; Digikey Part Number PEC11R-4215F-N0024-ND
U101, U103: 74HC595; SOIC-16_3.9x9.9mm_Pitch1.27mm; MFG Part Number 74HC595D,118; LCSC Part Number C5947
U102: MCP23S17; SOIC-28W_7.5x18.7mm_Pitch1.27mm; MFG Part Number MCP23S17-E/SO; LCSC Part Number C145413

Connections:
+5V: C101.1, C102.1, C103.1, C104.1, C105.1, C106.1, C107.1, C108.1, C109.1, J101.1, Q101.2 (E), Q102.2 (E), Q103.2 (E), R119.1, R122.1, RV101.1, RV102.1, RV103.1, RV104.1, U101.10 (~SRCLR), U101.16 (VCC), U102.9 (VCC), U103.10 (~SRCLR), U103.16 (VCC)
/A0: SW101.2, U102.1 (GPB0)
/A1: SW102.2, U102.2 (GPB1)
/A2: SW103.2, U102.3 (GPB2)
/A3: SW104.2, U102.4 (GPB3)
/A4: SW105.2, U102.5 (GPB4)
/A5: SW106.2, U102.6 (GPB5)
/A6: SW107.2, U102.7 (GPB6)
/A7: R103.1, U102.8 (GPB7)
AD1: J102.1, RV101.2
AD2: J102.2, RV102.2
AD3: J102.3, RV103.2
AD4: J102.4, RV104.2
CS0: J102.15, U102.11 (~CS)
CS1: J102.11, U101.12 (RCLK)
CS1A: J101.3, U103.12 (RCLK)
CV: J102.8, J108.3
ClockIn: J102.10, Q104.3 (C), R119.2
ClockOut: J102.6, J105.3
DIG1: J101.4, R115.2
DIG2: J101.5, R116.2
DIG3: J101.6, R117.2
ENC1: J101.10, SW116.A
ENC2: J101.9, SW116.B
GND: C101.2, C102.2, C103.2, C104.2, C105.2, C106.2, C107.2, C108.2, C109.2, D1.2 (A), D109.1 (K), J101.7, J101.8, J104.1, J105.1, J106.1, J107.1, J108.1, J109.1, Q104.2 (E), Q105.2 (E), R114.1, R121.2, R124.2, RV101.3, RV102.3, RV103.3, RV104.3, SW101.1, SW102.1, SW103.1, SW104.1, SW105.1, SW106.1, SW107.1, SW116.C, U101.8 (GND), U101.13 (~OE), U102.10 (GND), U102.15 (A0), U102.16 (A1), U102.17 (A2), U103.8 (GND), U103.13 (~OE)
Gate: D1.1 (K), D118.2 (A), J102.5, R118.2
MISO: J102.14, U102.14 (SO)
MOSI: J102.13, U101.14 (SER), U102.13 (SI)
unnamed: D101.1 (K), D105.1 (K), D110.1 (K), D114.1 (K), U101.4 (QE)
unnamed: D101.2 (A), D102.2 (A), D103.2 (A), D104.2 (A), R101.2
unnamed: D102.1 (K), D106.1 (K), D111.1 (K), D115.1 (K), U101.5 (QF)
unnamed: D103.1 (K), D107.1 (K), D112.1 (K), D116.1 (K), U101.6 (QG)
unnamed: D104.1 (K), D108.1 (K), D113.1 (K), D117.1 (K), U101.7 (QH)
unnamed: D105.2 (A), D106.2 (A), D107.2 (A), D108.2 (A), R102.1
unnamed: D109.2 (A), R103.2
unnamed: D110.2 (A), D111.2 (A), D112.2 (A), D113.2 (A), R104.1
unnamed: D114.2 (A), D115.2 (A), D116.2 (A), D117.2 (A), R105.1
unnamed: D118.1 (K), R114.2
unnamed: J103.1 (E), R110.2
unnamed: J103.2 (D), R109.2
unnamed: J103.3 (DP), R113.2
unnamed: J103.4 (C), R108.2
unnamed: J103.5 (G), R112.2
unnamed: J103.7 (B), R107.2
unnamed: J103.8 (DIGIT_3), Q103.3 (C)
unnamed: J103.9 (DIGIT_2), Q102.3 (C)
unnamed: J103.10 (F), R111.2
unnamed: J103.11 (A), R106.2
unnamed: J103.12 (DIGIT_1), Q101.3 (C)
unnamed: J104.3, R118.1
unnamed: J106.3, R120.2
unnamed: J109.3, R123.2
unnamed: Q101.1 (B), R115.1
unnamed: Q102.1 (B), R116.1
unnamed: Q103.1 (B), R117.1
unnamed: Q104.1 (B), R120.1, R121.1
unnamed: Q105.1 (B), R123.1, R124.1
unnamed: R101.1, U101.15 (QA)
unnamed: R102.2, U101.1 (QB)
unnamed: R104.2, U101.2 (QC)
unnamed: R105.2, U101.3 (QD)
unnamed: R106.1, U103.15 (QA)
unnamed: R107.1, U103.1 (QB)
unnamed: R108.1, U103.2 (QC)
unnamed: R109.1, U103.3 (QD)
unnamed: R110.1, U103.4 (QE)
unnamed: R111.1, U103.5 (QF)
unnamed: R112.1, U103.6 (QG)
unnamed: R113.1, U103.7 (QH)
unnamed: SW108.1, SW109.1, SW110.1, SW111.1, U102.28 (GPA7)
unnamed: SW108.2, SW112.2, SW117.2, SW121.2, U102.24 (GPA3)
unnamed: SW109.2, SW113.2, SW118.2, SW122.2, U102.23 (GPA2)
unnamed: SW110.2, SW114.2, SW119.2, SW123.2, U102.22 (GPA1)
unnamed: SW111.2, SW115.2, SW120.2, SW124.2, U102.21 (GPA0)
unnamed: SW112.1, SW113.1, SW114.1, SW115.1, U102.27 (GPA6)
unnamed: SW117.1, SW118.1, SW119.1, SW120.1, U102.26 (GPA5)
unnamed: SW121.1, SW122.1, SW123.1, SW124.1, U102.25 (GPA4)
unnamed: U101.9 (QH'), U103.14 (SER)
Pitch: J102.7, J107.3
ResetIn: J102.9, Q105.3 (C), R122.2
SCK: J102.12, U101.11 (SRCLK), U102.12 (SCK)
SCKA: J101.2, U103.11 (SRCLK)
SPI_Reset: J102.16, U102.18 (~RESET)

Notes on the sheet:
ANALOG KNOBS
FUNCTION BUTTONS
INPUT/OUTPUT JACKS
LED MATRIX

Board: 2 copper layers, 100.0 x 110.0 mm, 97 parts (2 on the bottom side), 83 nets.

File kicad-control-board-smt/bom-onboard/kicad-control-board-smt-bom-smt-only.xlsx:

Comment | Quantity | Do Not Install | Reference Designators | Footprint | Vendor | Vendor Part # | MFG Part # | Manufacturer
47uF | 3 |  | C101,C104,C107 | Capacitors_SMD:CP_Elec_6.3x7.7 | Digikey | 493-2225-6-ND | UWT1H470MCL1GS | Nichicon
100nF | 3 |  | C102,C105,C108 | Capacitors_SMD:C_0603_HandSoldering | Digikey | 399-1100-6-ND | C0603C104Z3VACTU | Kemet
100pF | 3 |  | C103,C106,C109 | Capacitors_SMD:C_0603_HandSoldering | Digikey | 399-7821-6-ND | C0603C101J1GACTU | Kemet
SS54 | 1 |  | D1 | Diodes_SMD:D_SMA_Handsoldering | Digikey | TSS54URGGDKR-ND | TSS54U RGG | Taiwan Semiconductor
LED | 18 | DNI | D105,D114,D115,D111,D106,D102,D103,D107,D112,D116,D117,D113,D108,D104,D110,D101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 | LEDs:LED_D3.0mm | Digikey | 160-1940-ND | LTL-1CHA | Lite-On
Conn_01x10_Female | 1 | DNI | J101 | Pin_Headers:Pin_Header_Straight_1x10_Pitch2.54mm | Digikey | S7008-ND | PPTC101LFBN-RC | Sullins
Conn_01x16_Female | 1 | DNI | J102 | Pin_Headers:Pin_Header_Straight_1x16_Pitch2.54mm | Digikey | S7014-ND | PPTC161LFBN-RC | Sullins
BA56_3DIG_7SEG | 1 | DNI | J103 | Eurocad:BA56_3DIG_7SEG | Digikey | 754-1656-5-ND | BA56-12GWA | Kingbright
3.5mm jacks | 6 | DNI | J104,J105,J106,J107,J108,J109 | Eurocad:PJ301M-12 | N/A | N/A | WQP-WQP518MA | Qingpu
MMBT3906 | 3 |  | Q101,Q102,Q103 | TO_SOT_Packages_SMD:SOT-23_Handsoldering | Digikey | MMBT3906LT1GOSDKR-ND | MMBT3906LT1G | ON Semiconductor
MMBT3904 | 2 |  | Q104,Q105 | TO_SOT_Packages_SMD:SOT-23_Handsoldering | Digikey | MMBT3904LT3GOSDKR-ND | MMBT3904LT3G | ON Semiconductor
100R | 12 |  | R101,R102,R104,R105,R106,R107,R108,R109,R110,R111,R112,R113 | Resistors_SMD:R_0603_HandSoldering | Digikey | RMCF0603FT100RDKR-ND | RMCF0603FT100R | Stackpole Electronics Inc
1k | 3 |  | R114,R118,R103 | Resistors_SMD:R_0603_HandSoldering | Digikey | RMCF0603FT1K00DKR-ND | RMCF0603FT1K00 | Stackpole Electronics Inc
680R | 3 |  | R115,R116,R117 | Resistors_SMD:R_0603_HandSoldering | Digikey | RMCF0603FT680RCT-ND | RMCF0603FT680R | Stackpole Electronics Inc
10k | 2 |  | R119,R122 | Resistors_SMD:R_0603_HandSoldering | Digikey | RMCF0603FT10K0DKR-ND | RMCF0603FT10K0 | Stackpole Electronics Inc
100k | 2 |  | R120,R123 | Resistors_SMD:R_0603_HandSoldering | Digikey | RMCF0603FG100KDKR-ND | RMCF0603FG100K | Stackpole Electronics Inc
1M | 2 |  | R121,R124 | Resistors_SMD:R_0603_HandSoldering | Digikey | RMCF0603FT1M00DKR-ND | RMCF0603FT1M00 | Stackpole Electronics Inc
R_POT | 4 | DNI | RV102,RV103,RV104,RV101 | Potentiometers:Potentiometer_Alps_RK09K_Horizontal | Digikey | N/A |  | Alpha
SW_PUSH_12mm | 2 | DNI | SW106,SW105 | Buttons_Switches_THT:Push_E-Switch_KS01Q01 | Digikey | 401-1992-ND | D6R40 F2 LFS | C&K
SW_Push_6mm | 21 | DNI | SW101,SW102,SW103,SW104,SW107,SW112,SW109,SW110,SW113,SW114,SW115,SW117,SW118,S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 | Buttons_Switches_THT:SW_PUSH_6mm | Digikey | EG1861-ND | TL1105SPF160Q | E-Switch
Rotary_Encoder | 1 | DNI | SW116 | Rotary_Encoder:RotaryEncoder_Alps_EC12E_Vertical_H20mm | Digikey | PEC11R-4215F-N0024-ND | PEC11R-4215F-N0024 | Bourns, Inc
74HC595 | 2 |  | U101,U103 | Housings_SOIC:SOIC-16_3.9x9.9mm_Pitch1.27mm | Digikey | 1727-2821-6-ND | 74HC595D,118 | Nexperia USA, Inc
MCP23S17 | 1 |  | U102 | Housings_SOIC:SOIC-28W_7.5x18.7mm_Pitch1.27mm | Digikey | MCP23S17-E/SO-ND | MCP23S17-E/SO | Microchip

Notices in the files:
kicad-control-board-smt/kicad-control-board-smt.kicad_pcb:
SUPER SIXTEEN SMD v1.4 © 2020
